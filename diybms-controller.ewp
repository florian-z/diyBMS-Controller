# IAR project diybms-controller.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: RX600 Generic RX600
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCIncludePath2: C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_ICU; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_IWDT; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_LVD1; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_PORT; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_RIIC0_PWR; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_RSPI0_Shunt; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI0_CellModule; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI1_Display; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI5_CellModule; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI6_USB; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI8_CellModule; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI9_CellModule; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_TMR0_TMR1; C:\Projekte\forschung\diybms-controller\src\smc_gen\general; C:\Projekte\forschung\diybms-controller\src\smc_gen\r_bsp; C:\Projekte\forschung\diybms-controller\src\smc_gen\r_config; C:\Projekte\forschung\diybms-controller\src\smc_gen\r_pincfg; lib\RX130; lib\unified\logger
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  ICCRX.CCIncludePath2: C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_ICU; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_IWDT; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_LVD1; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_PORT; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_RIIC0_PWR; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_RSPI0_Shunt; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI0_CellModule; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI1_Display; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI5_CellModule; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI6_USB; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI8_CellModule; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_SCI9_CellModule; C:\Projekte\forschung\diybms-controller\src\smc_gen\Config_TMR0_TMR1; C:\Projekte\forschung\diybms-controller\src\smc_gen\general; C:\Projekte\forschung\diybms-controller\src\smc_gen\r_bsp; C:\Projekte\forschung\diybms-controller\src\smc_gen\r_config; C:\Projekte\forschung\diybms-controller\src\smc_gen\r_pincfg
  group (top)
    ./: diybms-controller.ipcf main.c process_message.c
  group lib
    lib/RX130/: uart.c
  group Renesas_AP/smc_gen/Config_ICU
    src/smc_gen/Config_ICU/: Config_ICU.c Config_ICU.h Config_ICU_user.c
  group Renesas_AP/smc_gen/Config_IWDT
    src/smc_gen/Config_IWDT/: Config_IWDT.c Config_IWDT.h Config_IWDT_user.c
  group Renesas_AP/smc_gen/Config_LVD1
    src/smc_gen/Config_LVD1/: Config_LVD1.c Config_LVD1.h Config_LVD1_user.c
  group Renesas_AP/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_AP/smc_gen/Config_RIIC0_PWR
    src/smc_gen/Config_RIIC0_PWR/: Config_RIIC0_PWR.c Config_RIIC0_PWR.h Config_RIIC0_PWR_user.c
  group Renesas_AP/smc_gen/Config_RSPI0_Shunt
    src/smc_gen/Config_RSPI0_Shunt/: Config_RSPI0_Shunt.c Config_RSPI0_Shunt.h Config_RSPI0_Shunt_user.c
  group Renesas_AP/smc_gen/Config_SCI0_CellModule
    src/smc_gen/Config_SCI0_CellModule/: Config_SCI0_CellModule.c Config_SCI0_CellModule.h Config_SCI0_CellModule_user.c
  group Renesas_AP/smc_gen/Config_SCI1_Display
    src/smc_gen/Config_SCI1_Display/: Config_SCI1_Display.c Config_SCI1_Display.h Config_SCI1_Display_user.c
  group Renesas_AP/smc_gen/Config_SCI5_CellModule
    src/smc_gen/Config_SCI5_CellModule/: Config_SCI5_CellModule.c Config_SCI5_CellModule.h Config_SCI5_CellModule_user.c
  group Renesas_AP/smc_gen/Config_SCI6_USB
    src/smc_gen/Config_SCI6_USB/: Config_SCI6_USB.c Config_SCI6_USB.h Config_SCI6_USB_user.c
  group Renesas_AP/smc_gen/Config_SCI8_CellModule
    src/smc_gen/Config_SCI8_CellModule/: Config_SCI8_CellModule.c Config_SCI8_CellModule.h Config_SCI8_CellModule_user.c
  group Renesas_AP/smc_gen/Config_SCI9_CellModule
    src/smc_gen/Config_SCI9_CellModule/: Config_SCI9_CellModule.c Config_SCI9_CellModule.h Config_SCI9_CellModule_user.c
  group Renesas_AP/smc_gen/Config_TMR0_TMR1
    src/smc_gen/Config_TMR0_TMR1/: Config_TMR0_TMR1.c Config_TMR0_TMR1.h Config_TMR0_TMR1_user.c
  group Renesas_AP/smc_gen/general
    src/smc_gen/general/: r_cg_hardware_setup.c r_cg_icu.h r_cg_iwdt.h r_cg_lvd.h r_cg_macrodriver.h r_cg_port.h r_cg_riic.h r_cg_rspi.h r_cg_sci.h r_cg_tmr.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/smc_gen/r_bsp/board/generic_rx130
    src/smc_gen/r_bsp/board/generic_rx130/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h
  group Renesas_AP/smc_gen/r_bsp/board/user
    src/smc_gen/r_bsp/board/user/: r_bsp.h
  group Renesas_AP/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an1685ej0620-rx-bsp.pdf
  group Renesas_AP/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an1685jj0620-rx-bsp.pdf
  group Renesas_AP/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: fsp_common_api.h lowlvl.c lowlvl.h lowsrc.c lowsrc.h mcu_locks.c r_bsp_common.c r_bsp_common.h r_bsp_cpu.c r_bsp_interrupts.c r_bsp_interrupts.h r_bsp_locking.c r_bsp_mcu_startup.c r_bsp_mcu_startup.h r_bsp_software_interrupt.c r_bsp_software_interrupt.h r_fsp_error.h r_rtos.h r_rx_compiler.h r_rx_intrinsic_functions.c r_rx_intrinsic_functions.h r_typedefs.h resetprg.c
  group Renesas_AP/smc_gen/r_bsp/mcu/rx130
    src/smc_gen/r_bsp/mcu/rx130/: mcu_clocks.c mcu_clocks.h mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.h r_bsp_cpu.h r_bsp_locking.h vecttbl.c vecttbl.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx130/register_access/iccrx
    src/smc_gen/r_bsp/mcu/rx130/register_access/iccrx/: iodefine.h
  group Renesas_AP/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt
  group Renesas_AP/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
